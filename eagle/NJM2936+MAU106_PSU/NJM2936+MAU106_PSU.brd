# Repository ryood/-5V_PSU

## EAGLE design eagle/NJM2936+MAU106_PSU/NJM2936+MAU106_PSU.brd

Parts:
C1: 0.33uF; C050-030X075
C2: 0.1uF; C025-024X044
C3: 470uF; SANYO-OSCON_F13
C4, C5: 100uF; SANYO-OSCON_C6
CN1: PWIN; B2B-XH-A
CN2, CN3, CN4, CN5: DPWR; B2B-XH-A
D1: 1S4; DO35-7
IC1: NJM2396V; TO220-4V
IC2: MAU106
JP1: WATCH; 1X02
JP2: PWIN; 1X02
JP3: TP_GND; 1X02
L1: EV20
LED1: GREEN; LED3MM
LED2: RED; LED3MM
LED3: BLUE; LED3MM
R1, R3: 1k; 0207/7
R2: 680; 0207/7
R4, R5: 100k; 0207/7
SL1, SL2, SL3: APWR; 03P

Connections:
A+5V: C5.+, IC2.P$6 (+VOUT), R1.2, SL1.3, SL2.3, SL3.3
A-5V: C4.-, IC2.P$4 (-VOUT), R2.2, SL1.1, SL2.1, SL3.1
D+5V: C2.1, C3.+, CN2.2, CN3.2, CN4.2, CN5.2, D1.A, IC1.2 (VO), IC2.P$1 (+VIN), R3.2, R4.2
GND: C1.2, C2.2, C3.-, C4.+, C5.-, CN2.1, CN3.1, CN4.1, CN5.1, IC1.3 (GND), IC2.P$2 (-VIN), IC2.P$5 (GND), JP1.2, JP3.1, JP3.2, L1.2, LED1.K (C), LED2.K (C), LED3.A, R5.1, SL1.2, SL2.2, SL3.2
unnamed: CN1.2, JP2.2, L1.3
unnamed: C1.1, D1.C, IC1.1 (VI), IC1.4 (CTL), L1.4
unnamed: CN1.1, JP2.1, L1.1
unnamed: LED1.A, R3.1
unnamed: LED2.A, R1.1
unnamed: LED3.K (C), R2.1
W+2V5: JP1.1, R4.1, R5.2

Notes on the sheet:
※IC2はSIPソケットで実装

Board: 2 copper layers, 93.7 x 71.1 mm, 28 parts (0 on the bottom side), 11 nets.

## Commit log

2017-11-10 Add NJM2396+MAU106 Test
2017-11-14 Add eagle files
2017-11-15 Add some image files
2017-11-17 Add テスト表
